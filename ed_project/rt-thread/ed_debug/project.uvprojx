# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, STM32G474xx
  c include: libraries\STM32G4xx_HAL\CMSIS\Device\ST\STM32G4xx\Include;board\CubeMX_Config\Inc;libraries\HAL_Drivers;applications;rt-thread\components\libc\compilers\common\extension;libraries\STM32G4xx_HAL\STM32G4xx_HAL_Driver\Inc;libraries\HAL_Drivers\CMSIS\Include;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;rt-thread\libcpu\arm\common;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;rt-thread\include;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;board;libraries\HAL_Drivers\drivers;libraries\HAL_Drivers\drivers\config;rt-thread\components\libc\compilers\common\extension\fcntl\octal;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/CubeMX_Config/Src/: stm32g4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
    libraries/STM32G4xx_HAL/CMSIS/Device/ST/STM32G4xx/Source/Templates/arm/: startup_stm32g474xx.s
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/STM32G4xx_HAL/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pwr.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cryp.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_dma.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_rng.c stm32g4xx_hal_crc.c stm32g4xx_hal_cryp_ex.c
    libraries/STM32G4xx_HAL/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
  group rt_kprintf
    packages/rt_kprintf_threadsafe-latest/: rt_kprintf.c
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
