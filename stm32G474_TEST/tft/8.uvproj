# Keil uVision project 8.uvproj, settings and files
target Target_1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: 8 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 1.C
